# Keil uVision project 03a.uart_mode0_output.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 03a-uart_mode0_output +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Library\lib_at89
  link misc: ru
  group Source Group 1
    ./: main.c
    ../../Library/lib_at89/: delay.c
